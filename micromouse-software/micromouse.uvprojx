# Keil uVision project micromouse.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F405RGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: micromouse +hex
  c flags: Optim=2 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c
  group Source
    ./source/: uart.c gpio.c clock.c adc.c buzzer.c ui.c motors.c circular_buffer.c
  group Include
    ./include/: uart.h gpio.h clock.h adc.h buzzer.h ui.h motors.h circular_buffer.h
software components: CMSIS:CORE 5.4.0, Device:Startup 2.6.3
